# Keil uVision project Project_IAP_B.uvprojx, settings and files
target ANIMAL_IAP_B (6120000::V6.12::C:\Keil_v5\Backup.001\ARM\ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ANIMAL_IAP_B +hex
  AfterMake: C:\Keil_v5\Backup.001\ARM\ARMCLANG\bin\fromelf.exe --bin -o ".\output\ANIMAL_IAP_B\ANIMAL_IAP_B.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F407,BOOT_APP_BASE=0x08040000
  c include: ..\Drivers\CMSIS\GD\GD32F4xx\Include;..\Drivers\CMSIS;..\Drivers\GD32F4xx_standard_peripheral\Include;..\Core;..\Bsp;..\Service;..\App;..\Protocol;..\Services;..\User;..\;..\BootSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: IAP_B.sct
  group Application
    ../Core/: gd32f4xx_it.c systick.c main.c
  group Service
    ../Service/: audio.c
    ../Services/: input_service.c coin_service.c win_collect_service.c
  group Game Application
    ../App/: app_main.c
    ../User/: game_authority.c settings_flash.c game_settings.c winner_control.c
    ../Protocol/: machine_protocol.c
  group Protocol
    ../Protocol/: protocol_parser.c protocol_builder.c
  group BSP
    ../Bsp/: output.c input.c usart.c at24cs64.c pcf8563.c i2c0.c board_io.c board_timer.c serial_port.c
  group GD32F4xx_Peripherals
    ../Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ../Drivers/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Startup
    ../Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group BootSupport
    ../BootSupport/: boot_contract.c
